# Keil uVision project ST7735.uvproj, settings and files
target Lab2 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --cpp
  c include: ..\RTOS_CppL3;..\..\..;.\os;.\hardware;.\graphics;.\data_structures;.\helper;.\file_system;.\can;.\inc;.\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Retarget.c ADC.c cr4_fft_64_stm32.s Lab6.c
    ./graphics/: ST7735.c
    ./hardware/: PLL.c Switch.c SysTickInts.c Timer.c UART0.c
    ./helper/: Perf.c priority.c
    ./os/: osasm.s os.c TCB.c
    ./file_system/: edisk.c efile.c FAT32.c
  group drivers
    ./driverlib/: gpio.c interrupt.c ssi.c cpu.c sysctl.c uart.c can.c
    ./can/: can0.c
